Commit message: 修复urdf中的right_thigh_joint的方向。将readme的内容同步到readme_zh中

File: robots/agilepf/agilepf.urdf (robot description, URDF)
Before this commit: robot agilepf, 9 links, 8 joints
Joints:
- joint right_thigh_joint: axis 0 -1 0 -> 0 1 0
